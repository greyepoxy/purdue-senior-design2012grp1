# Keil uVision project PIT_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM9XE256 Atmel
  cpu: IRAM(0x300000-0x307FFF) IROM(0x200000-0x23FFFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: PIT_test
  c flags: Optim=1
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x300000 size 0x8000
  group Header Files
    ./header files/at91sam9xe256/: AT91SAM9XE256.h
    ./header files/: pit.h board.h aic.h tc.h twi.h assert.h dbgu.h math.h pio.h trace.h TCM8230.h isi.h
  group Source Code
    ./header files/: pit.c aic.c tc.c twi.c dbgu.c math.c pio.c TCM8230.c isi.c
    ./: main.c
  group Startup Code
    ./: SAM9XE.s
